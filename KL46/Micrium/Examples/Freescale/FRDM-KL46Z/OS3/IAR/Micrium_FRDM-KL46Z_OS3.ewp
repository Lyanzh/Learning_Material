# IAR project Micrium_FRDM-KL46Z_OS3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\BSP; ..\..\BSP\IAR; ..\..\BSP\OS\uCOS-III; ..\..\BSP\Freescale; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uC-LIB\Ports\ARM-Cortex-M0\IAR; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Micrium_FRDM-KL46Z_OS3.srec
  ILINK.IlinkOutputFile: Micrium_FRDM-KL46Z_OS3.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_lcd.c bsp_lcd.h cpu_bsp.c
  group BSP/Freescale
    ../../BSP/Freescale/: MKL46Z4.h
  group BSP/IAR
    ../../BSP/IAR/: cstartup.c
  group BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M0/IAR
    ../../../../../Software/uC-CPU/ARM-Cortex-M0/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III/Ports/ARM-Cortex-M0/Generic/IAR
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
